# Keil uVision project waterctrl.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: waterctrl +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./code/: main.c wimiDevTimerManger.c wimiDevTimerStruct.c wimiDevTimerManger.h wimiDevTimerStruct.h global.c global.h seg.c seg.h waterctrl.c waterctrl.h keyscan.c keyscan.h AdDa.c AdDA.h pidctrl.c pidctrl.h
